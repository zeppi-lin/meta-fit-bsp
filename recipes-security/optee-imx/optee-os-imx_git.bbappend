PLATFORM_FLAVOR_fit-v2        = "mx6qsabresd"
